# Keil uVision project Vector_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: evm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c i2c.c keypad.c lcd.c otp.c uart.c delay.h i2c.h i2c_define.h keypad.h lcd.h otp.h type.h uart.h main.c
